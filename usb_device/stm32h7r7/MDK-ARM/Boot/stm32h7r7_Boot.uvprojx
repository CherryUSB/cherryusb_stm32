# Keil uVision project stm32h7r7_Boot.uvprojx, settings and files
target stm32h7r7_Boot (6240000::V6.24::ARMCLANG)
  device: STM32H7R7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h7r7_Boot +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R7xx
  c include: ../../Boot/Core/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include;../../../../CherryUSB/common;../../../../CherryUSB/core;../../../../CherryUSB/class/cdc;../../../../CherryUSB/class/hid;../../../../CherryUSB/class/msc;../../../../CherryUSB/class/audio;../../../../CherryUSB/class/video;../../../../CherryUSB/class/hub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: stm32h7r7xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7r7xx.s
  group Application/User/Boot/Core
    ../../../../CherryUSB/demo/: cdc_acm_msc_template.c
    ../../Boot/Core/Src/: main.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group CherryUSB
    ../../../../CherryUSB/core/: usbd_core.c
    ../../../../CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../../../../CherryUSB/class/hid/: usbd_hid.c
    ../../../../CherryUSB/class/msc/: usbd_msc.c
    ../../../../CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c
software components: CMSIS:CORE 4.3.0
