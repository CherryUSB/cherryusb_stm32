# IAR project stm32h7s3_Boot.ewp, settings and files
configuration stm32h7s3_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx
  ICCARM.CCIncludePath2: ../../Boot/Core/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../../../CherryUSB/common; ../../../../CherryUSB/core; ../../../../CherryUSB/class/cdc; ../../../../CherryUSB/class/hid; ../../../../CherryUSB/class/video; ../../../../CherryUSB/class/audio; ../../../../CherryUSB/class/hub
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32h7s3_Boot.hex
  ILINK.IlinkOutputFile: stm32h7s3_Boot.out
  ILINK.IlinkIcfFile: stm32h7s3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot/Core
    ../../Boot/Core/Src/: main.c main_user.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c stm32h7rsxx_it_user.c
  group Application/User/USB
    ../../../../CherryUSB/demo/: cdc_acm_template.c
  group CherryUSB
    ../../../../CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
    ../../../../CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../../../../CherryUSB/core/: usbd_core.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_usb.c
