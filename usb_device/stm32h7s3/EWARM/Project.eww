<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\stm32h7s3_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
