# Keil uVision project stm32h7r7_Boot.uvprojx, settings and files
target stm32h7r7_Boot (6140001::V6.14.1::ARMCLANG)
  device: STM32H7R7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h7r7_Boot +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R7xx
  c include: ../../Boot/Core/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include;../../../../CherryUSB/common;../../../../CherryUSB/core;../../../../CherryUSB/class/cdc;../../../../CherryUSB/class/hid;../../../../CherryUSB/class/msc;../../../../CherryUSB/class/audio;../../../../CherryUSB/class/video;../../../../CherryUSB/class/hub;..\..\..\..\CherryUSB\third_party\FreeRTOS-10.4\include;..\..\..\..\CherryUSB\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM7\r0p1;..\..\..\..\CherryUSB\third_party\fatfs-0.14\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: .\stm32h7r7xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7r7xx.s
  group Application/User/Boot/Core
    ../../Boot/Core/Src/: main.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
    ../../../../CherryUSB/demo/: usb_host.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c
  group CherryUSB
    ../../../../CherryUSB/port/dwc2/: usb_glue_st.c usb_hc_dwc2.c
    ../../../../CherryUSB/osal/: usb_osal_freertos.c
    ../../../../CherryUSB/core/: usbh_core.c
    ../../../../CherryUSB/class/cdc/: usbh_cdc_acm.c
    ../../../../CherryUSB/class/hid/: usbh_hid.c
    ../../../../CherryUSB/class/msc/: usbh_msc.c
    ../../../../CherryUSB/class/hub/: usbh_hub.c
  group FreeRTOS
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1/: port.c
  group FATFS
    ../../../../CherryUSB/third_party/fatfs-0.14/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../CherryUSB/platform/fatfs/: usbh_fatfs.c
software components: CMSIS:CORE 4.3.0
