# Keil uVision project stm32f429igt6.uvprojx, settings and files
target stm32f429igt6 (6140001::V6.14.1::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f429igt6 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\CherryUSB\common;..\..\..\CherryUSB\core;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\hub;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\class\msc;..\..\..\CherryUSB\class\wireless;..\..\..\CherryUSB\class\video;..\..\..\CherryUSB\class\audio;..\..\..\CherryUSB\osal;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\include;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM4F;..\..\..\CherryUSB\third_party\fatfs-0.14\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../../../CherryUSB/demo/: usb_host.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS
    ../../../CherryUSB/third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM4F/: port.c
  group CherryUSB
    ../../../CherryUSB/core/: usbh_core.c
    ../../../CherryUSB/class/hub/: usbh_hub.c
    ../../../CherryUSB/class/cdc/: usbh_cdc_acm.c
    ../../../CherryUSB/class/msc/: usbh_msc.c
    ../../../CherryUSB/class/hid/: usbh_hid.c
    ../../../CherryUSB/class/wireless/: usbh_rndis.c
    ../../../CherryUSB/class/audio/: usbh_audio.c
    ../../../CherryUSB/class/video/: usbh_video.c
    ../../../CherryUSB/osal/: usb_osal_freertos.c
    ../../../CherryUSB/port/dwc2/: usb_hc_dwc2.c
  group fatfs
    ../../../CherryUSB/third_party/fatfs-0.14/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../CherryUSB/third_party/fatfs-0.14/source/port/: fatfs_usbh.c
software components: CMSIS:CORE 5.4.0
